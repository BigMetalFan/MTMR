# Keil uVision project lab1.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: lab1
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F401xC
  c include: Include/;Src/;Headers/
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f401xc.s system_stm32f4xx.c
  group Include
    ./Include/: stm32f4xx.h stm32f401xc.h system_stm32f4xx.h
  group Src
    ./Src/: main.c rcc_conf.c delay.c led.c button.c font5x7.c ssd1306.c i2c.c encoder.c
  group Headers
    ./Headers/: delay.h main.h rcc_conf.h led.h button.h potent.h uartCommunication.h font5x7.h ssd1306.h i2c.h
software components: CMSIS:CORE 5.5.0
